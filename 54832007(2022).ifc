Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-19T15:40:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 15:40:49 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{C0C54D77-0BA3-4BA5-A3A4-25968820E4F9}\ifc * Database version: 5507 * Database creation date: Thu May 19 15:40:48 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 15:40:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 15:40:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 54832007 Bath faucet, floor mounting, 54832007(2022):54832007 Bath faucet, floor mounting:303145
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm
Type - General - Author: BIMstone; BIMObjectName: 54832007(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - Backflow Prevention EN1717: EB; EAN Number: 4057304017599; EN Standard: EN 817; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181810 Faucet trim; URL Declaration of Conformity: http://static.hansa.com/DoC/54832007; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/54832007; Catalog Drawing URL: http://static.hansa.com/catdrw/54832007; Dimension Drawing URL: http://static.hansa.com/dimdrw/54832007; FDV Document URL: http://www.hansa.com/datasheet/54832007/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/54832007; Group: Bath faucet; Interactive AR View URL: https://static.hansa.com/AR/54832007; Item Type: Sales item; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;France;Czech Republic;Slovakia;Italy;Spain; Mobile Product Information URL: http://mpi.hansa.com/54832007; Model: 54832007 Bath faucet, floor mounting; Name_en: 54832007 Bath faucet, floor mounting; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 54832007; Product Family: HANSAVANTIS Style; Product Image URL: http://static.hansa.com/image/54832007; Product URL: http://static.hansa.com/54832007; Technical DataSheet URL: http://www.hansa.com/datasheet/54832007/en; Type Name: 54832007 Bath faucet, floor mounting; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Connection Size: G1/2; Diverter: Pull operated diverter; Flow Rate At 300kPa: 12.0151 m3/s; Installation Type: Floor standing; Installation Width: CC150± 15 mm; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Shower Parts: Hand shower;Shower hose (1600 mm); Spout Projection: 209 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 54832007(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 54832007; Name: 54832007 Bath faucet, floor mounting; ReplacementCost: n/a; Shape: Sculptured; Size: 55x175x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.591497 m2; Volume: 0.0660888 m3
Identity Data - Mark: 5
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 54832007(2022): 54832007 Bath faucet, floor mounting; Family and Type: 54832007(2022): 54832007 Bath faucet, floor mounting; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 54832007(2022): 54832007 Bath faucet, floor mounting; Type Id: 54832007(2022): 54832007 Bath faucet, floor mounting; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
